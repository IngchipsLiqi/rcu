# Keil uVision project mi_rcu.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: mi_rcu +hex
  AfterMake: fromelf.exe --bin -o mi_rcu.bin ./output/mi_rcu.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,
  c include: .\src;.\src\audio\CMSIS\Include;..\sbc\sbc;.\src\project_common;.\src\rcu;../sdk/bundles/typical/inc;../sdk/bundles/typical/inc/os;../sdk/src/BSP;../sdk/src/FWlib;../sdk/src/StartUP/ing916;../sdk/src/Tools;../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x2028000 size 0x58000
  memory RVCT9: RAM 0x20005448 size 0x2bb8
  group APP
    ./src/: main.c profile.c mi_rcu_service.c mi_rcu_key.c mi_rcu_adv.c
  group StartUP
    ./src/: startup_ing91600.s
    ../sdk/bundles/typical/ING9168xx/: symdefs.m
  group BSP
    ../sdk/src/BSP/: eflash.c board.c
  group FWlib
    ../sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_dma.c peripheral_ir.c peripheral_keyscan.c
  group Tools
    ../sdk/src/Tools/: trace.c att_db_util.c
  group audio
    ./src/audio/: audio_service.c pingpong.c audio_input_sim.c audio_msbc.o audio_denoise.c
  group CMSIS
    ./src/audio/CMSIS/Source/TransformFunctions/: TransformFunctions.c
    ./src/audio/CMSIS/Source/CommonTables/: CommonTables.c
    ./src/audio/CMSIS/Source/FastMathFunctions/: FastMathFunctions.c
    ./src/audio/CMSIS/Source/BasicMathFunctions/: BasicMathFunctions.c
    ./src/audio/CMSIS/Source/MatrixFunctions/: MatrixFunctions.c
    ./src/audio/CMSIS/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ./src/audio/CMSIS/Source/StatisticsFunctions/: StatisticsFunctions.c
  group sbc
    ./src/audio/: sbc_primitives.o sbc.o
  group common
    ./src/project_common/: sdk_private_flash_data.c low_power.c kv_impl.c
  group rcu
    ./src/rcu/: pair_bond.c key_board.c keyscan_bsp.c VR_key.c ir_sim.c
software components: CMSIS:CORE 4.3.0
